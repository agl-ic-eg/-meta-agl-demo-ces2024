IMAGE_INSTALL += " \
    packagegroup-agl-demo-music-data \
    tzdata \
    can-utils can-utils-access \
"

IMAGE_LINGUAS = "en-us ja-jp"
